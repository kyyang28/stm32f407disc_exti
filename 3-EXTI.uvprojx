# Keil uVision project 3-EXTI.uvprojx, settings and files
target STM32F407VG-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 3-EXTI
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\src\lib\CMSIS\CM4\CoreSupport;.\src\lib\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;.\src\lib\STM32F4xx_StdPeriph_Drivers\inc;.\src\quad\build;.\src\quad\common;.\src\quad\config;.\src\quad\drivers;.\src\quad\fc;.\src\quad\target\3-EXTI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./src/quad/startup/: startup_stm32f407xx.s
  group STM32F4xx_StdPeriph_Drivers
    ./src/lib/STM32F4xx_StdPeriph_Drivers/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group TARGET
    ./src/quad/target/3-EXTI/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./src/quad/drivers/: system.c
  group DRIVERS
    ./src/quad/drivers/: button.c exti.c io.c led.c rcc.c
  group FC
    ./src/quad/fc/: config.c
